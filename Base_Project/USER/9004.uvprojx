# Keil uVision project 9004.uvprojx, settings and files
target 9004 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 9004 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c FreeRTOSConfig.h
    ./RunParame/: runParame.c
    ./RunPage/: runPage.c
    ./app/: app.c
    ./myComProcess/: myComProcess.c
  group HARDWARE
    ../HARDWARE/TM1621/: TM1621.c
    ../HARDWARE/CS1237/: cs1237.c
    ../HARDWARE/Flash/: rwFlash.c
    ../HARDWARE/Key/: key.c
    ../HARDWARE/Usart/: usart.c
    ../HARDWARE/Dma/: bsp_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_tim.c
  group README
    ../: README.TXT
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c portmacro.h
